## boards/shields/sandvich/Kconfig.defconfig
```kconfig
if SHIELD_SANDVICH

config ZMK_KEYBOARD_NAME
    default "sandvich"

endif # SHIELD_SANDVICH
```
